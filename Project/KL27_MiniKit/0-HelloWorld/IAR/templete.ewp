# IAR project templete.ewp, settings and files
configuration mkl27z4 (ARM, debug)
  General.OGChipSelectEditMenu: MKL27Z128xxx4 Freescale MKL27Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: MKL27Z4; DEBUG
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\Libraries\drivers\KL\inc; ..\..\..\..\Libraries\devices\inc; ..\..\..\..\Libraries\startup\CoreSupport; ..\..\..\..\Libraries\startup\DeviceSupport\IAR-ARM; ..\..\..\..\Libraries\startup\DeviceSupport
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: templete.bin
  ILINK.IlinkOutputFile: templete.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group devices
    ../../../../Libraries/devices/src/: at24cxx.c w25qxx.c
  group drivers
    ../../../../Libraries/drivers/KL/src/: common.c dma.c gpio.c i2c.c lpuart.c spi.c systick.c
  group startup
    ../../../../Libraries/startup/DeviceSupport/IAR-ARM/: startup_MKL27Z4.s
    ../../../../Libraries/startup/DeviceSupport/: system_MKL27Z4.c
  group user
    ../src/: main.c
