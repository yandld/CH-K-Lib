# Keil uVision project templete.uvproj, settings and files
target mk64f12 (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale Semiconductor
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: templete
  c flags: Optim=1 uC99=1
  c define: MK64F12 CLOCK_SETUP=0 RAVEN
  c include: ..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\drivers\K\inc;..\..\..\..\Libraries\devices\inc;..\..\..\..\Libraries\utilities\board;..\..\..\..\Libraries\utilities\imu;..\..\..\..\Libraries\drivers\K\src\usb\inc;..\..\..\..\Libraries\utilities\veep
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group startup_mk64f12
    ../../../../Libraries/startup/DeviceSupport/: system_MK64F12.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK64F12.s
  group user
    ../src/: main.c trans.c protocol.c
    ../../../../Libraries/utilities/veep/: virtual_eep.c
  group drivers
    ../../../../Libraries/drivers/K/src/: gpio.c common.c systick.c i2c.c uart.c wdog.c dma.c pit.c flash.c
  group utilities
    ../../../../Libraries/utilities/imu/: filter.c imu.c calibration.c
  group devices
    ../../../../Libraries/devices/src/: mpu9250.c bmp180.c
  group USBStack
    ../../../../Libraries/drivers/K/src/usb/src/: usbd_cdc_acm.c usbd_core.c usbd_core_cdc.c
