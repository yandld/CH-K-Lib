# Keil uVision project templete.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20002FFF) IROM(0x0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: templete
  c flags: Optim=1
  c define: MKL25Z4
  c misc: --c99
  c include: ..\..\..\Libraries\startup\CoreSupport;..\..\..\Libraries\startup\DeviceSupport;..\..\..\Libraries\drivers\KL\inc;..\..\..\Libraries\utilities\minishell;..\..\..\Libraries\utilities\shell
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x3000
  group startup
    ../../../Libraries/startup/DeviceSupport/: system_MKL25Z4.c
    ../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MKL25Z4.s
  group user
    ../src/: isr.c main.c
  group drivers
    ../../../Libraries/drivers/KL/src/: gpio.c
