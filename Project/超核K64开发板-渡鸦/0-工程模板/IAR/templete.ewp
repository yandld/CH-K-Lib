# IAR project templete.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK61FN1M0xxx12 Freescale MK61FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: MK64F12; DEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\Libraries\drivers\K\inc; ..\..\..\..\Libraries\startup\CoreSupport; ..\..\..\..\Libraries\startup\DeviceSupport\IAR-ARM; ..\..\..\..\Libraries\startup\DeviceSupport
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: templete.srec
  ILINK.IlinkOutputFile: templete.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Freescale\MK60xN512_10.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  ICCARM.CCDefines: NDEBUG; MK60D10
  ICCARM.CCOptLevel: 3
  group drivers
    ../../../../Libraries/drivers/K/src/: adc.c common.c cpuidy.c dma.c enet.c flexbus.c ftm.c gpio.c i2c.c lptmr.c pit.c rtc.c sd.c spi.c systick.c tsi.c uart.c wdog.c
  group startup
    ../../../../Libraries/startup/DeviceSupport/IAR-ARM/: startup_MK64F12.s
    ../../../../Libraries/startup/DeviceSupport/: system_MK64F12.c
  group user
    ../src/: main.c
