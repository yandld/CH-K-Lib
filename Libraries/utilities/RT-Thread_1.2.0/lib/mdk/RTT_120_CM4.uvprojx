# Keil uVision project RTT_120_CM4.uvprojx, settings and files
target rtt_cm4 (5060020::V5.06 (build 20)::ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.4.3.0
  cpu: CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: ..\..\RTT_CM4 (library)
  c flags: Optim=4 uC99=1
  c misc: --c99
  c include: ..\..\include;..\src;..\..\components\finsh;..\..\components\dfs\include;..\..\components\drivers\include;..\..\components\drivers\include\drivers;..\..\components\drivers\i2c;..\..\components\net\lwip-1.4.1\src;..\..\components\net\lwip-1.4.1\src\include;..\..\components\net\lwip-1.4.1\src\arch\include;..\..\components\net\lwip-1.4.1\src\include\netif;..\..\components\net\lwip-1.4.1\src\include\ipv4;..\..\components\utilities\logtrace;..\..\components\dfs\filesystems\ramfs;..\..\components\dfs\filesystems\romfs;..\..\..\..\startup\DeviceSupport;..\..\..\..\startup\CoreSupport;..\..\components\dfs\filesystems\nfs;..\..\components\drivers\include\drivers;..\..\components\init
  library: MicroLIB
  link misc: --keep __rtmsym_*   --keep __fsym_* --keep __vsym_*   --keep __rt_init*
  group rtt-kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group rtt-finsh
    ../../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c shell.c symbol.c msh_file.c
  group rtt-dfs
    ../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../components/dfs/filesystems/elmfat/option/: ccfile.c
  group rtt-driver-struct
    ../../components/drivers/mtd/: mtd_nand.c mtd_nor.c
    ../../components/drivers/rtc/: alarm.c rtc.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/spi/: spi_core.c spi_dev.c enc28j60.c spi_flash_at45dbxx.c spi_flash_sst25vfxx.c spi_flash_w25qxx.c spi_wifi_rw009.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c
    ../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../components/drivers/misc/: pin.c
  group config
    ../src/: rtconfig.h
  group app_start
    ../src/: startup.c
  group lwip_core
    ../../components/net/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../components/net/lwip-1.4.1/src/core/snmp/: asn1_dec.c asn1_enc.c mib_structs.c mib2.c msg_in.c msg_out.c
    ../../components/net/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group lwip_arch
    ../../components/net/lwip-1.4.1/src/arch/: sys_arch.c
  group lwip_api
    ../../components/net/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip_netif
    ../../components/net/lwip-1.4.1/src/netif/: etharp.c ethernetif.c slipif.c
    ../../components/net/lwip-1.4.1/src/netif/ppp/: auth.c chap.c chpms.c fsm.c ipcp.c lcp.c magic.c md5.c pap.c ppp.c ppp_oe.c randm.c vj.c
  group rtt_dfs_ramfs
    ../../components/dfs/filesystems/ramfs/: dfs_ramfs.c
  group rtt_dfs_romfs
    ../../components/dfs/filesystems/romfs/: dfs_romfs.c romfs.c
  group rtt_coretx_m4
    ../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group rtt_nfs
    ../../components/dfs/filesystems/nfs/: dfs_nfs.c mount_clnt.c mount_xdr.c nfs_clnt.c nfs_xdr.c
    ../../components/dfs/filesystems/nfs/rpc/: auth_none.c clnt_generic.c clnt_udp.c pmap.c rpc_prot.c xdr.c xdr_mem.c
  group rtt_compnents/init
    ../../components/init/: components.c
  group rtt_example/kernel
    ../../examples/kernel/: cpuusage.c
