# Keil uVision project templete.uvprojx, settings and files
target mk60d10 (5060020::V5.06 (build 20)::ARMCC)
  device: MK60DN512xxx10 Freescale Semiconductor
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") CLOCK(100000000) ELITTLE
  output: templete +hex
  c flags: Optim=1
  c define: MK60D10 RAVEN DEBUG
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\drivers\K\inc;..\..\..\..\Libraries\utilities\inc;..\..\..\..\Libraries\devices\inc;..\src;..\..\..\..\Libraries\znfat;..\..\..\..\Libraries\emWin\Include;..\..\..\..\Libraries\emWin\Sample\LCD_X;..\..\..\..\Libraries\utilities\uCOSII\config;..\..\..\..\Libraries\utilities\uCOSII\core;..\..\..\..\Libraries\utilities\uCOSII\port
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group startup_mk60d10
    ../../../../Libraries/startup/DeviceSupport/: system_MK60D10.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK60D10.s
  group startup_mk64f12
    ../../../../Libraries/startup/DeviceSupport/: system_MK64F12.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK64F12.s
  group user
    ../src/: main.c
  group drivers
    ../../../../Libraries/drivers/K/src/: gpio.c uart.c wdog.c pit.c cpuidy.c adc.c ftm.c i2c.c spi.c lptmr.c dma.c flexbus.c systick.c rtc.c enet.c tsi.c common.c sd.c
  group uCOSII_Core
    ../../../../Libraries/utilities/uCOSII/core/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOSII_Config
    ../../../../Libraries/utilities/uCOSII/config/: includes.h os_cfg.h
  group uCOSII_Port
    ../../../../Libraries/utilities/uCOSII/port/: os_cpu_a_keil.asm os_cpu_c.c os_dbg.c
target mk64f12 (5060020::V5.06 (build 20)::ARMCC)
  device: MK64FN1M0xxx12 Freescale
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: templete +hex
  c flags: Optim=1
  c define: MK64F12  RAVEN DEBUG
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
