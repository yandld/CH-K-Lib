# Keil uVision project templete.uvproj, settings and files
target mk60d10 (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x3000) IRAM2(0x1FFFF000,0x1000) CPUTYPE("Cortex-M0+") CLOCK(48000000) ELITTLE
  output: templete +hex
  c flags: Optim=1
  c define: MKL25Z4 LIB_ DEBUG
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\drivers\KL\inc;..\..\..\..\Libraries\utilities\inc;..\..\..\..\Libraries\devices\inc;..\src;..\..\..\..\Libraries\znfat;..\..\..\..\Libraries\emWin\Include;..\..\..\..\Libraries\emWin\Sample\LCD_X
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x1ffff000 size 0x1000
  group startup
    ../../../../Libraries/startup/DeviceSupport/: system_MKL25Z4.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MKL25Z4.s
  group user
    ../src/: main.c
  group drivers
    ../../../../Libraries/drivers/KL/src/: common.c
