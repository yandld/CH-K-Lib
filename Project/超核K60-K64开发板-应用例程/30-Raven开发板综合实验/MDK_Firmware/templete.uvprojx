# Keil uVision project templete.uvprojx, settings and files
target mk60d10 (5060020::V5.06 (build 20)::ARMCC)
  device: MK60DN512xxx10 Freescale Semiconductor
  pack: Keil.Kinetis_K60_DFP.1.0.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") CLOCK(100000000) ELITTLE
  output: templete +hex
  AfterMake: fromelf --bin !L --output templete.bin
  c flags: Optim=4
  c define: MK60D10 RAVEN
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\drivers\K\inc;..\src_firmware\gui;..\src_firmware;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\include;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\finsh;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\dfs\include;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\dfs\filesystems\nfs;..\..\..\..\Libraries\utilities\emWin\Include;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\drivers\include\drivers;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\drivers\spi;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\drivers\include;..\..\..\..\Libraries\devices\inc;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\bsp\Reven;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\init;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\net\lwip-1.4.1\src;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\net\lwip-1.4.1\src\arch\include;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\net\lwip-1.4.1\src\include;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\net\lwip-1.4.1\src\include\ipv4;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\net\lwip-1.4.1\src\include\netif;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\lib\src;..\..\..\..\Libraries\utilities\board;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\dfs\filesystems\romfs;..\..\..\..\Libraries\utilities\USBStack\inc;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\init;..\..\..\..\Libraries\utilities\emWin\Sample\GUIDemo
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  link misc: --keep __fsym_*  --keep __vsym_*   --symdefs=api_mk60.sym
  group lib_startup_mk60d10
    ../../../../Libraries/startup/DeviceSupport/: system_MK60D10.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK60D10.s
  group lib_startup_mk64f12
    ../../../../Libraries/startup/DeviceSupport/: system_MK64F12.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK64F12.s
  group application
    ../src_firmware/: raven_box.c usb_lib.c usb_thread.c application.c
    ../../../../Libraries/utilities/RT-Thread_1.2.0/components/finsh/: msh_cmd.c
  group lib-drivers
    ../../../../Libraries/drivers/K/src/: gpio.c uart.c pit.c cpuidy.c adc.c ftm.c i2c.c spi.c dma.c flexbus.c systick.c rtc.c enet.c common.c sd.c lptmr.c flash.c
  group rtt-driver
    ../../../../Libraries/utilities/RT-Thread_1.2.0/bsp/Reven/: drv_uart.c drv_data_flash.c drv_rtc.c drv_sd.c drv_spi.c drv_ads7843.c drv_at24cxx.c drv_lcd.c drv_pin.c drv_i2c_bit_ops.c drv_enet_phy.c
    ../../../../Libraries/devices/src/: ili9320.c IS61WV25616.c enet_phy.c
    ../../../../Libraries/utilities/RT-Thread_1.2.0/components/drivers/misc/: pin.c
    ../../../../Libraries/utilities/RT-Thread_1.2.0/components/drivers/rtc/: rrtc.c
    ../../../../Libraries/utilities/RT-Thread_1.2.0/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
  group RTTLib
    ../../../../Libraries/utilities/RT-Thread_1.2.0/lib/: RTT_CM4.lib
    ../../../../Libraries/utilities/RT-Thread_1.2.0/lib/src/: startup.c
  group config
    ../../../../Libraries/utilities/RT-Thread_1.2.0/lib/src/: rtconfig.h
  group lwip\apps
    ../../../../Libraries/utilities/RT-Thread_1.2.0/examples/network/: tcpclient.c tcpsendpacket.c tcpserver.c udpclient.c udpserver.c wget.c
    ../../../../Libraries/utilities/RT-Thread_1.2.0/components/net/lwip-1.3.2/apps/: ftpd.c ping.c tftp.c telnet.c chargen.c netio.c sntp.c
  group USBStack
    ../../../../Libraries/utilities/USBStack/src/: usbd_core.c usbd_core_msc.c usbd_kk.c usbd_msc.c usbd_core_hid.c usbd_hid.c
  group demo
    ../../../../Libraries/utilities/RT-Thread_1.2.0/examples/test/: device_test.c fs_test.c mem_test.c
target mk64f12 (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: templete +hex
  AfterMake: fromelf --bin !L --output templete.bin
  c flags: Optim=4
  c define: MK64F12 RAVEN
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\drivers\K\inc;..\src_firmware\gui;..\src_firmware;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\include;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\finsh;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\dfs\include;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\dfs\filesystems\nfs;..\..\..\..\Libraries\utilities\emWin\Include;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\drivers\include;..\..\..\..\Libraries\devices\inc;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\bsp\Reven;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\init;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\net\lwip-1.4.1\src;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\net\lwip-1.4.1\src\arch\include;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\net\lwip-1.4.1\src\include;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\net\lwip-1.4.1\src\include\ipv4;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\net\lwip-1.4.1\src\include\netif;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\lib\src;..\..\..\..\Libraries\utilities\board;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\dfs\filesystems\romfs;..\src\webserver;..\..\..\..\Libraries\utilities\USBStack\inc;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\init;..\src_firmware\gui;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\drivers\spi;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\drivers\include\drivers
  memory RVCT4: ROM 0x0 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  link misc: --keep __rtmsym_*   --keep __fsym_* --keep __vsym_*   --keep __rt_init*   --symdefs=api_mk64.sym
