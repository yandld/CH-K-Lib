# Keil uVision project templete.uvproj, settings and files
target mk64f12 (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: templete +hex
  AfterMake: fromelf --bin !L --output templete.bin
  c flags: Optim=4
  c define: MK64F12 FRDM LIB_DEBUG
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\drivers\K\inc;..\src\gui;..\src;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\include;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\finsh;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\dfs\include;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\dfs\filesystems\nfs;..\..\..\..\Libraries\utilities\emWin\Include;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\drivers\include;..\..\..\..\Libraries\devices\inc;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\bsp\Reven;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\init;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\net\lwip-1.4.1\src;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\net\lwip-1.4.1\src\arch\include;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\net\lwip-1.4.1\src\include;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\net\lwip-1.4.1\src\include\ipv4;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\net\lwip-1.4.1\src\include\netif;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\lib\src
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_*
  group lib-startup
    ../../../../Libraries/startup/DeviceSupport/: system_MK64F12.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK64F12.s
  group application
    ../src/: main.c startup.c init_thread.c led_thread.c sd_thread.c websrv.c
  group lib-drivers
    ../../../../Libraries/drivers/K/src/: gpio.c uart.c pit.c dma.c flexbus.c systick.c enet.c common.c sd.c spi.c
  group lib-devices
    ../../../../Libraries/devices/src/: ili9320.c sram.c ksz8041.c
  group rtt-driver
    ../../../../Libraries/utilities/RT-Thread_1.2.0/bsp/Reven/: rtt_ksz8041.c rtt_sd.c rtt_serial.c rtt_spi.c
  group kernel_examples
    ../../../../Libraries/utilities/RT-Thread_1.2.0/examples/kernel/: cpuusage.c event_simple.c heap_malloc.c heap_realloc.c mbox_send_wait.c mbox_simple.c memp_simple.c messageq_simple.c mutex.c mutex_simple.c sem.c semaphore_buffer_worker.c semaphore_dynamic.c semaphore_priority.c semaphore_producer_consumer.c semaphore_static.c tc_comm.c tc_sample.c thread_critical_var.c thread_delay.c thread_delete.c thread_detach.c thread_dynamic.c thread_dynamic_simple.c thread_priority.c thread_resume.c thread_same_priority.c thread_static.c thread_static_simple.c thread_suspend.c thread_yield.c timer_control.c timer_dynamic.c timer_static.c timer_stop_self.c timer_timeout.c
  group hw_test_examples
    ../../../../Libraries/utilities/RT-Thread_1.2.0/examples/test/: fs_test.c
  group fs_examples
    ../../../../Libraries/utilities/RT-Thread_1.2.0/examples/file/: listdir.c readspeed.c readwrite.c seekdir.c writespeed.c
  group net_examples
    ../../../../Libraries/utilities/RT-Thread_1.2.0/examples/network/: dns_demo.c nfs.c tcpclient.c tcpsendpacket.c tcpserver.c udpclient.c udpserver.c
  group rtt-cortexM4
    ../../../../Libraries/utilities/RT-Thread_1.2.0/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../../../Libraries/utilities/RT-Thread_1.2.0/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group RTT_120
    ../../../../Libraries/utilities/RT-Thread_1.2.0/lib/: RTT_120_CM4.lib
  group msh_cmd
    ../../../../Libraries/utilities/RT-Thread_1.2.0/components/finsh/: msh_cmd.c
  group lwip-core
    ../../../../Libraries/utilities/RT-Thread_1.2.0/components/net/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../../../Libraries/utilities/RT-Thread_1.2.0/components/net/lwip-1.4.1/src/core/snmp/: asn1_dec.c asn1_enc.c mib_structs.c mib2.c msg_in.c msg_out.c
    ../../../../Libraries/utilities/RT-Thread_1.2.0/components/net/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group lwip-api
    ../../../../Libraries/utilities/RT-Thread_1.2.0/components/net/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip-arch
    ../../../../Libraries/utilities/RT-Thread_1.2.0/components/net/lwip-1.4.1/src/arch/: sys_arch.c
  group lwip-netif
    ../../../../Libraries/utilities/RT-Thread_1.2.0/components/net/lwip-1.4.1/src/netif/: etharp.c ethernetif.c slipif.c
    ../../../../Libraries/utilities/RT-Thread_1.2.0/components/net/lwip-1.4.1/src/netif/ppp/: auth.c chap.c chpms.c fsm.c ipcp.c lcp.c magic.c md5.c pap.c ppp.c ppp_oe.c randm.c vj.c
  group config
    ../../../../Libraries/utilities/RT-Thread_1.2.0/lib/src/: rtconfig.h
