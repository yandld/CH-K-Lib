# Keil uVision project templete.uvproj, settings and files
target mk60d10 (ARM-ADS)
  device: MK60DN512xxx10 Freescale Semiconductor
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") CLOCK(100000000) ELITTLE
  output: templete +hex
  c flags: Optim=1
  c define: MK60D10 RAVEN DEBUG
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\drivers\K\inc;..\..\..\..\Libraries\devices\inc;..\src;..\..\..\..\Libraries\znfat;..\..\..\..\Libraries\utilities\ucGUI\inc;..\..\..\..\Libraries\utilities\ucGUI\inc\Config;..\..\..\..\Libraries\utilities\fatfs
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group startup
    ../../../../Libraries/startup/DeviceSupport/: system_MK60D10.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK60D10.s
  group user
    ../src/: main.c
  group drivers
    ../../../../Libraries/drivers/K/src/: gpio.c uart.c wdog.c pit.c cpuidy.c adc.c ftm.c i2c.c spi.c lptmr.c dma.c flexbus.c systick.c rtc.c enet.c tsi.c common.c sd.c dac.c
  group devices
    ../../../../Libraries/devices/src/: sram.c ili9320.c w25qxx.c spi_bus_ops.c ads7843.c nrf24l01.c
  group fatfs
    ../../../../Libraries/utilities/fatfs/: diskio.c ff.c
  group uCGUI
    ../../../../Libraries/utilities/ucGUI/build/MDK/obj/: GUILib.lib
    ../../../../Libraries/devices/src/: ucGuiFunc.c
