# Keil uVision project templete.uvproj, settings and files
target mk60d10_flash (ARM-ADS)
  device: MK60DN512xxx10 Freescale Semiconductor
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") CLOCK(100000000) ELITTLE
  output: templete +hex
  AfterMake: fromelf --bin !L --output ./OBJ/flash/templete.bin
  c flags: Optim=1
  c define: MK60D10 RAVEN DEBUG
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\drivers\K\inc;..\..\..\..\Libraries\utilities\inc;..\..\..\..\Libraries\devices\inc;..\src;..\..\..\..\Libraries\znfat;..\..\..\..\Libraries\emWin\Include;..\..\..\..\Libraries\emWin\Sample\LCD_X
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group startup
    ../../../../Libraries/startup/DeviceSupport/: system_MK60D10.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK60D10.s
  group user
    ../src/: main.c
  group drivers
    ../../../../Libraries/drivers/K/src/: gpio.c uart.c wdog.c pit.c cpuidy.c adc.c ftm.c i2c.c spi.c lptmr.c dma.c flexbus.c systick.c rtc.c enet.c tsi.c common.c sd.c can.c vref.c
target mk60d10_bootloader (ARM-ADS)
  device: MK60DN512xxx10 Freescale Semiconductor
  cpu: as above
  output: templete_bootloader +hex
  AfterMake: fromelf --bin !L --output ./OBJ/bootloader/templete.bin
  c flags: Optim=1
  c define: MK60D10 RAVEN DEBUG
  c misc: --c99
  c include: as above
  asm define: BOOTLOADER
  memory RVCT4: ROM 0x5000 size 0x7b000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
