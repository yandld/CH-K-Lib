# Keil uVision project templete.uvproj, settings and files
target mkl27z4 (ARM-ADS)
  device: MKL27Z64xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.6.0
  cpu: IROM(0x00000000,0x10000) IRAM(0x1FFFF000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: templete +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 uC99=1
  c define: MKL27Z4 MINI_KIT
  c include: ..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\drivers\KL\src\usb\inc;..\..\..\..\Libraries\drivers\KL\inc;..\..\..\..\Libraries\utilities\inc;..\..\..\..\Libraries\devices\inc;..\src
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group startup_mkl27z4
    ../../../../Libraries/startup/DeviceSupport/: system_MKL27Z4.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MKL27Z4.s
  group user
    ../src/: main.c usb_lib.c usb_config.h
  group drivers
    ../../../../Libraries/drivers/KL/src/: common.c gpio.c systick.c lpuart.c spi.c i2c.c dma.c adc.c flash.c
  group devices
    ../../../../Libraries/devices/src/: w25qxx.c at24cxx.c
  group USBStack
    ../../../../Libraries/drivers/KL/src/usb/src/: usbd_core.c usbd_core_msc.c usbd_msc.c usbd_kk.c
  group readme
    ../: readme.md
