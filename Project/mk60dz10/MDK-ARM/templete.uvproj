# Keil uVision project templete.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: MK60DN256xxx10 Freescale Semiconductor
  cpu: IRAM(0x1FFF8000-0x1FFFFFFF) IRAM2(0x20000000-0x20007FFF) IROM(0x0-0x4FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: templete
  c flags: Optim=1
  c misc: --c99
  c include: ..\..\Libraries\startup\CoreSupport;..\..\Libraries\startup\DeviceSupport;..\..\Libraries\drivers\inc;..\..\Libraries\utilities\minishell
  memory RVCT4: ROM 0x0 size 0x50000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
