# Keil uVision project templete.uvprojx, settings and files
target mk64f12_flash (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MK64FN1M0xxx12 Freescale Semiconductor
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: templete +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1
  c define: MK64F12
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\drivers\K\inc;..\..\..\..\Libraries\utilities\inc;..\..\..\..\Libraries\devices\inc;..\src;..\..\..\..\Libraries\utilities\lwip;..\..\..\..\Libraries\utilities\lwip\lwip-1.4.1\include;..\..\..\..\Libraries\utilities\lwip\lwip-1.4.1\include\ipv4;..\..\..\..\Libraries\utilities\lwip\lwip-1.4.1\include\lwip;..\..\..\..\Libraries\utilities\lwip\lwip-1.4.1\netif;..\..\..\..\Libraries\utilities\lwip\arch
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group startup_mk64f12
    ../../../../Libraries/startup/DeviceSupport/: system_MK64F12.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK64F12.s
  group startup_mk60d10
    ../../../../Libraries/startup/DeviceSupport/: system_MK60D10.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK60D10.s
  group user
    ../src/: main.c udp_raw_demo.c tcp_raw_client_demo.c tcp_raw_server_demo.c
  group drivers
    ../../../../Libraries/drivers/K/src/: gpio.c uart.c pit.c systick.c common.c enet.c
  group devices
    ../../../../Libraries/devices/src/: enet_phy.c
  group lwip_api
    ../../../../Libraries/utilities/lwip/lwip-1.4.1/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip_netif
    ../../../../Libraries/utilities/lwip/lwip-1.4.1/netif/: etharp.c ethernetif.c slipif.c
  group lwip_arch
    ../../../../Libraries/utilities/lwip/arch/: sys_arch.c
  group lwip/core
    ../../../../Libraries/utilities/lwip/lwip-1.4.1/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group lwip/snmp
    ../../../../Libraries/utilities/lwip/lwip-1.4.1/core/snmp/: asn1_dec.c asn1_enc.c mib_structs.c mib2.c msg_in.c
  group lwip/ipv4
    ../../../../Libraries/utilities/lwip/lwip-1.4.1/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
target mk60d10_flash (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MK60DN512xxx10 Freescale Semiconductor
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") CLOCK(100000000) ELITTLE
  output: templete +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c define: MK60D10 CLOCK_SETUP=3
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
