# Keil uVision project templete.uvproj, settings and files
target mk60dz10 (ARM-ADS)
  device: MK60DN512xxx10 Freescale Semiconductor
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") CLOCK(100000000) ELITTLE
  output: templete
  AfterMake: fromelf --bin !L --output templete.bin
  c flags: Optim=1
  c define: MK60DZ10 CHK60EVB2 DEBUG
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\drivers\K\inc;..\..\..\..\Libraries\devices\inc;..\src;..\..\..\..\RT-Thread_1.2.0\include;..\..\..\..\RT-Thread_1.2.0\components\finsh;..\..\..\..\RT-Thread_1.2.0\components\dfs\include;..\..\..\..\RT-Thread_1.2.0\components\rtgui\include\rtgui;..\..\..\..\RT-Thread_1.2.0\components\rtgui\include;..\..\..\..\Libraries\emWin\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_*
  group startup
    ../../../../Libraries/startup/DeviceSupport/: system_MK60DZ10.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK60DZ10.s
  group user
    ../src/: main.c rtconfig.h startup.c led_tesk.c cpuusage.c kill.c device_test.c 25.c msh_cmd_bmp.c
  group drivers
    ../../../../Libraries/drivers/K/src/: gpio.c uart.c wdog.c pit.c cpuidy.c adc.c ftm.c i2c.c spi.c lptmr.c dma.c flexbus.c systick.c rtc.c enet.c tsi.c common.c sd.c
  group devices
    ../../../../Libraries/devices/src/: ili9320.c sram.c spi_abstraction.c ads7843.c w25qxx.c i2c_abstraction.c adxl345.c at24cxx.c
  group rtt-kernel
    ../../../../RT-Thread_1.2.0/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group rtt-cortex-m4
    ../../../../RT-Thread_1.2.0/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../../RT-Thread_1.2.0/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group rtt-finsh
    ../../../../RT-Thread_1.2.0/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c shell.c symbol.c
  group rtt-driver
    ../../../../RT-Thread_1.2.0/bsp/Reven/: rtt_serial.c rtt_sd.c rtt_ili9320.c
  group rtt-dfs
    ../../../../RT-Thread_1.2.0/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../../../../RT-Thread_1.2.0/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
  group emwin
    ../../../../Libraries/emWin/Lib/: GUI_CM3.lib
    ../../../../Libraries/emWin/: GUI_X.c GUIConf.c GUIConf.h LCDConf.c
