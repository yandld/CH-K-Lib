# Keil uVision project templete.uvproj, settings and files
target mkl03z4_flash (ARM-ADS)
  device: MKL03Z32xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.1.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x20000000,0x0600) IRAM2(0x1FFFFE00,0x0200) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: templete +hex
  AfterMake: fromelf --bin !L --output ./OBJ/flash/templete.bin
  c flags: Optim=1
  c define: MKL03Z4 RAVEN DEBUG
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\drivers\KL\inc;..\..\..\..\Libraries\utilities\inc;..\..\..\..\Libraries\devices\inc;..\src;..\..\..\..\Libraries\znfat;..\..\..\..\Libraries\emWin\Include;..\..\..\..\Libraries\emWin\Sample\LCD_X
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  group startup
    ../../../../Libraries/startup/DeviceSupport/: system_MKL03Z4.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MKL03Z4.s
  group user
    ../src/: main.c
  group drivers
    ../../../../Libraries/drivers/KL/src/: common.c gpio.c systick.c lpuart.c
