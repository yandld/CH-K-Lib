# IAR project templete.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: MK60D10; DEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\Libraries\drivers\K\inc; ..\..\..\..\Libraries\utilities\shell; ..\..\..\..\Libraries\startup\CoreSupport; ..\..\..\..\Libraries\startup\DeviceSupport\IAR-ARM; ..\..\..\..\Libraries\startup\DeviceSupport; ..\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: templete.out
  ILINK.IlinkIcfFile: ..\src\MK60xN512_10.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group drivers
    ../../../../Libraries/drivers/K/src/: adc.c common.c cpuidy.c dma.c enet.c flexbus.c ftm.c gpio.c i2c.c lptmr.c pit.c rtc.c sd.c spi.c systick.c tsi.c uart.c wdog.c
  group startup
    ../../../../Libraries/startup/DeviceSupport/IAR-ARM/: startup_MK60D10.s
    ../../../../Libraries/startup/DeviceSupport/: system_MK60D10.c
  group user
    ../src/: main.c
  group utilities
    ../../../../Libraries/utilities/shell/: shell.c shell_autocomplete.c shell_cmdhelp.c shell_cmdhist.c
