# Keil uVision project templete.uvproj, settings and files
target mk64f12_flash (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale Semiconductor
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: templete +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1
  c define: MK64F12
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\drivers\K\inc;..\..\..\..\Libraries\utilities\inc;..\..\..\..\Libraries\devices\inc;..\src;..\src\lwip-1.4.1;..\src\lwip-1.4.1\include;..\src\lwip-1.4.1\include\ipv4;..\src\lwip-1.4.1\include\lwip;..\src\lwip-1.4.1\netif;..\src\arch;..\src\lwip_app\lwip_comm
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group startup
    ../../../../Libraries/startup/DeviceSupport/: system_MK64F12.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK64F12.s
  group user
    ../src/: main.c lwipopts.h
  group drivers
    ../../../../Libraries/drivers/K/src/: gpio.c uart.c pit.c systick.c common.c enet.c
  group devices
    ../../../../Libraries/devices/src/: enet_phy.c
  group lwip_api
    ../src/lwip-1.4.1/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip_core
    ../src/lwip-1.4.1/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c lwip_timers.c
    ../src/lwip-1.4.1/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../src/lwip-1.4.1/core/snmp/: asn1_dec.c asn1_enc.c mib_structs.c mib2.c msg_in.c msg_out.c
    ../src/lwip-1.4.1/netif/ppp/: auth.c chap.c chpms.c fsm.c ipcp.c lcp.c magic.c md5.c pap.c ppp.c ppp_oe.c randm.c vj.c
  group lwip_netif
    ../src/lwip-1.4.1/netif/: etharp.c ethernetif.c
  group lwip_arch
    ../src/arch/: sys_arch.c
