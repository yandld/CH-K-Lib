# Keil uVision project templete.uvproj, settings and files
target mk60d10 (ARM-ADS)
  device: MK60DN512xxx10 Freescale Semiconductor
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") CLOCK(100000000) ELITTLE
  output: templete +hex
  c flags: Optim=1
  c define: MK60D10 RAVEN DEBUG CLOCK_SETUP=4
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\drivers\K\inc;..\..\..\..\Libraries\utilities\inc;..\..\..\..\Libraries\devices\inc;..\src;..\..\..\..\Libraries\znfat;..\..\..\..\Libraries\emWin\Include;..\..\..\..\Libraries\emWin\Sample\LCD_X;..\..\..\..\Libraries\drivers\K\src\usb\inc;..\..\..\..\Libraries\drivers\K\src\usb\src\descriptor\cdc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group startup
    ../../../../Libraries/startup/DeviceSupport/: system_MK60D10.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK60D10.s
  group user
    ../src/: main.c
  group drivers
    ../../../../Libraries/drivers/K/src/: gpio.c uart.c wdog.c pit.c cpuidy.c adc.c ftm.c i2c.c spi.c lptmr.c dma.c flexbus.c systick.c rtc.c enet.c tsi.c common.c sd.c
  group devices
    ../../../../Libraries/devices/src/: sram.c ili9320.c
  group driver\usb\commn
    ../../../../Libraries/drivers/K/src/usb/src/common/: usb.c usb_class.c usb_framework.c
  group driver\usb\dirver
    ../../../../Libraries/drivers/K/src/usb/src/driver/: usb_dci_kinetis.c usb_driver.c usbevent.c
  group driver\usb\class
    ../../../../Libraries/drivers/K/src/usb/src/descriptor/cdc/: usb_descriptor.c
    ../../../../Libraries/drivers/K/src/usb/src/class/cdc/: usb_cdc.c usb_cdc_pstn.c
