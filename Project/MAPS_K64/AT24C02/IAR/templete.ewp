# IAR project templete.ewp, settings and files
configuration mk64f12 (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: MK64F12; DEBUG
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\Libraries\drivers\K\inc; ..\..\..\..\Libraries\startup\CoreSupport; ..\..\..\..\Libraries\startup\DeviceSupport\IAR-ARM; ..\..\..\..\Libraries\startup\DeviceSupport; ..\..\..\..\Libraries\devices\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: templete.bin
  ILINK.IlinkOutputFile: templete.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group devices
    ../../../../Libraries/devices/src/: at24cxx.c
  group drivers
    ../../../../Libraries/drivers/K/src/: adc.c can.c common.c crc.c dac.c dma.c flexbus.c ftm.c gpio.c i2c.c lptmr.c pdb.c pit.c rtc.c sd.c spi.c systick.c uart.c vref.c wdog.c
  group statup_mk64f12
    ../../../../Libraries/startup/DeviceSupport/IAR-ARM/: startup_MK64F12.s
    ../../../../Libraries/startup/DeviceSupport/: system_MK64F12.c
  group user
    ../src/: main.c
