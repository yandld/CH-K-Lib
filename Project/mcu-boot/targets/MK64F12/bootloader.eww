<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\iar\raven_bootloader\raven_bootloader.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All configurations</name>
      <member>
        <project>tower_bootloader</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>tower_bootloader</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>freedom_bootloader</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>freedom_bootloader</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>flashloader</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>flashloader_loader</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>flashloader</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>flashloader_loader</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


