# Keil uVision project templete.uvprojx, settings and files
target mk60d10_flash (5060020::V5.06 (build 20)::ARMCC)
  device: MK60DN512xxx10 Freescale
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: templete +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1
  c define: MK60D10 CLOCK_SETUP=4
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\drivers\K\inc;..\..\..\..\Libraries\utilities\inc;..\..\..\..\Libraries\devices\inc;..\src;..\..\..\..\Libraries\utilities\lwip;..\..\..\..\Libraries\utilities\lwip\lwip-1.4.1\include;..\..\..\..\Libraries\utilities\lwip\lwip-1.4.1\include\ipv4;..\..\..\..\Libraries\utilities\lwip\lwip-1.4.1\include\lwip;..\..\..\..\Libraries\utilities\lwip\lwip-1.4.1\netif;..\..\..\..\Libraries\utilities\lwip\arch;..\..\..\..\Libraries\utilities\USBStack\inc;..\..\..\..\Libraries\utilities\fatfs
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group startup_mk60d10
    ../../../../Libraries/startup/DeviceSupport/: system_MK60D10.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK60D10.s
  group user
    ../src/: main.c udp_demo.c usb_lib.c udisk.c diskio.c
  group drivers
    ../../../../Libraries/drivers/K/src/: gpio.c uart.c pit.c systick.c common.c enet.c can.c flash.c
  group devices
    ../../../../Libraries/devices/src/: enet_phy.c
  group lwip_api
    ../../../../Libraries/utilities/lwip/lwip-1.4.1/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip_netif
    ../../../../Libraries/utilities/lwip/lwip-1.4.1/netif/: etharp.c ethernetif.c slipif.c
  group lwip_arch
    ../../../../Libraries/utilities/lwip/arch/: sys_arch.c
  group lwip/core
    ../../../../Libraries/utilities/lwip/lwip-1.4.1/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group lwip/snmp
    ../../../../Libraries/utilities/lwip/lwip-1.4.1/core/snmp/: asn1_dec.c asn1_enc.c mib_structs.c mib2.c msg_in.c
  group lwip/ipv4
    ../../../../Libraries/utilities/lwip/lwip-1.4.1/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group USBStack
    ../../../../Libraries/utilities/USBStack/src/: usbd_core.c usbd_core_msc.c usbd_kk.c usbd_msc.c
  group fatfs
    ../../../../Libraries/utilities/fatfs/: ff.c
