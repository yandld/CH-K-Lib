# IAR project templete.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN256xxx10 Freescale MK60DN256xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\Libraries\startup\CoreSupport; ..\..\Libraries\startup\DeviceSupport\IAR-ARM; ..\..\Libraries\startup\DeviceSupport; ..\..\Libraries\drivers\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: templete.out
  ILINK.IlinkIcfFile: config\128KB_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: config\128KB_Pflash.icf
  group Drivers
    ../../Libraries/drivers/src/: gpio.c sys.c uart.c
  group Startup
    ../../Libraries/startup/DeviceSupport/IAR-ARM/: crt0.s startup.c startup_MK70F12.s system_MK60DZ10.c
  group User
    ../src/: isr.c main.c
