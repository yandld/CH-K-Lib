# Keil uVision project templete.uvproj, settings and files
target mk10d7 (ARM-ADS)
  device: MK10DX128xxx7 Freescale
  pack: Keil.Kinetis_K10_DFP.1.0.0
  cpu: IROM(0x00000000,0x20000) IROM2(0x10000000,0x8000) IRAM(0x20000000,0x4000) IRAM2(0x1FFFC000,0x4000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: templete +hex
  AfterMake: fromelf --bin !L --output ./mk60d10/flash/templete.bin
  c flags: Optim=1
  c define: MK10D7
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\drivers\K\inc;..\..\..\..\Libraries\utilities\inc;..\..\..\..\Libraries\devices\inc;..\src;..\..\..\..\Libraries\znfat;..\..\..\..\Libraries\emWin\Include;..\..\..\..\Libraries\emWin\Sample\LCD_X
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x1fffc000 size 0x4000
  group startup_mk10d7
    ../../../../Libraries/startup/DeviceSupport/: system_MK10D7.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK10D7.s
  group user
    ../src/: main.c
  group drivers
    ../../../../Libraries/drivers/K/src/: gpio.c uart.c wdog.c pit.c cpuidy.c adc.c ftm.c i2c.c spi.c lptmr.c dma.c flexbus.c systick.c rtc.c enet.c tsi.c common.c sd.c can.c cmp.c crc.c dac.c pdb.c vref.c
