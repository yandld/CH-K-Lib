# Keil uVision project templete.uvproj, settings and files
target mkl26z4 (ARM-ADS)
  device: MKL25Z64xxx4 Freescale Semiconductor
  cpu: IROM(0x00000000,0x10000) IRAM(0x1FFFF800,0x2000) CPUTYPE("Cortex-M0+") CLOCK(48000000) ELITTLE
  output: templete
  c flags: Optim=4 uC99=1
  c define: MKL26Z4 CLOCK_SETUP=0 CHLIB_DMA_SUPPORT=1 FRDM
  c include: ..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\drivers\KL\inc;..\..\..\..\Libraries\devices\inc;..\..\..\..\Libraries\utilities\board;..\..\..\..\Libraries\utilities\imu;..\..\..\..\Libraries\utilities\veep;..\src;..\..\..\..\Libraries\drivers\K\src\usb_test\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x1ffff800 size 0x2000
  group startup_mkl26z4
    ../../../../Libraries/startup/DeviceSupport/: system_MKL26Z4.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MKL26Z4.s
  group user
    ../src/: main.c message_manage.c
  group drivers
    ../../../../Libraries/drivers/KL/src/: common.c dma.c flash.c gpio.c i2c.c pit.c uart.c
  group USBStack
    ../../../../Libraries/drivers/K/src/usb_test/src/: usb_hid.c usbd.c usbd_desc.c
