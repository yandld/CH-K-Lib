# Keil uVision project templete.uvproj, settings and files
target mk60d10 (ARM-ADS)
  device: MK60DN512xxx10 Freescale Semiconductor
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") CLOCK(100000000) ELITTLE
  output: templete +hex
  AfterMake: fromelf --bin !L --output templete.bin
  c flags: Optim=4
  c define: MK60D10 RAVEN
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\drivers\K\inc;..\src\gui;..\src;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\include;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\finsh;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\dfs\include;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\dfs\filesystems\nfs;..\..\..\..\Libraries\utilities\emWin\Include;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\drivers\include;..\..\..\..\Libraries\devices\inc;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\bsp\Reven;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\init;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\net\lwip-1.4.1\src;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\net\lwip-1.4.1\src\arch\include;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\net\lwip-1.4.1\src\include;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\net\lwip-1.4.1\src\include\ipv4;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\net\lwip-1.4.1\src\include\netif;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\lib\src;..\..\..\..\Libraries\utilities\board;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\dfs\filesystems\romfs;..\src\webserver;..\..\..\..\Libraries\drivers\K\src\usb\inc;..\..\..\..\Libraries\drivers\K\src\usb\src\descriptor\msd;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\init;..\..\..\..\Libraries\utilities\emWin\Sample\GUIDemo
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  link misc: --keep __rtmsym_*   --keep __fsym_* --keep __vsym_*   --keep __rt_init*
  group lib_startup_mk60d10
    ../../../../Libraries/startup/DeviceSupport/: system_MK60D10.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK60D10.s
  group lib_startup_mk64f12
    ../../../../Libraries/startup/DeviceSupport/: system_MK64F12.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK64F12.s
  group application
    ../src/gui/: my_gui.c
    ../src/: sd_thread.c
    ../src/sys_core/: gui_service.c init_thread.c key_service.c led_service.c usb_service.c network_service.c
    ../src/gui/apps/: simple_beep.c
  group lib-drivers
    ../../../../Libraries/drivers/K/src/: gpio.c uart.c pit.c cpuidy.c adc.c ftm.c i2c.c spi.c dma.c flexbus.c systick.c rtc.c enet.c common.c sd.c lptmr.c
  group lib-devices
    ../../../../Libraries/devices/src/: ili9320.c sram.c ksz8041.c
  group rtt-driver
    ../../../../Libraries/utilities/RT-Thread_1.2.0/bsp/Reven/: rtt_ili9320.c rtt_ksz8041.c rtt_rtc.c rtt_sd.c rtt_spi.c touch_ads7843.c rtt_beep.c rtt_i2c_bit_ops.c i2c_at24cxx.c rtt_led.c rtt_iflash.c drv_uart.c
  group emwin
    ../src/gui/config/: GUI_X.c GUIConf.c LCDConf.c
    ../../../../Libraries/utilities/emWin/Lib/: GUI_CM4F_L.lib GUI_CM3.lib
  group gui_apps
    ../src/gui/apps/: auto_calibration.c
    ../src/gui/: gui_app.c
  group gui_diolag
    ../src/gui/dialog/notepad/: gui_notepad.c
    ../src/gui/dialog/calander/: gui_calendar.c
    ../src/gui/dialog/calculator/: calculator.c
    ../src/gui/dialog/calibration/: calibration.c
    ../src/gui/dialog/clock/: gui_clock.c
    ../src/gui/dialog/desktop/: gui_desktop.c
    ../src/gui/dialog/file/: gui_choosefile.c
    ../src/gui/dialog/image/: gui_image.c
    ../src/gui/dialog/info/: gui_sysinfo.c
    ../src/gui/dialog/tasker/: tasker.c tasker_page1.c tasker_page2.c
  group rtt_examples/net
    ../../../../Libraries/utilities/RT-Thread_1.2.0/examples/network/: tcpclient.c tcpsendpacket.c tcpserver.c udpclient.c udpserver.c
  group RTT_120
    ../../../../Libraries/utilities/RT-Thread_1.2.0/lib/: RTT_CM4.lib
  group config
    ../../../../Libraries/utilities/RT-Thread_1.2.0/lib/src/: rtconfig.h
  group app/web
    ../src/webserver/: fs.c httpd.c ssi_cgi_handle.c
  group lwip\apps
    ../../../../Libraries/utilities/RT-Thread_1.2.0/components/net/lwip-1.3.2/apps/: ftpd.c ping.c tftp.c telnet.c chargen.c netio.c sntp.c tcpecho.c udpecho.c
  group application\msh_cmd
    ../src/msh_cmd/: kill_thread.c reset.c nfs.c sys_cmd_nent.c device_test.c fs_test.c gui_cmd_demo.c gui_cmd_info.c gui_cmd_screenshot.c
    ../../../../Libraries/utilities/RT-Thread_1.2.0/components/finsh/: msh_cmd.c
    ../../../../Libraries/utilities/RT-Thread_1.2.0/components/dfs/filesystems/nfs/: dfs_nfs.c
  group emwin/demos
    ../../../../Libraries/utilities/emWin/Sample/GUIDemo/: GUIDEMO.c GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
  group driver\usb\class
    ../../../../Libraries/drivers/K/src/usb/src/descriptor/msd/: usb_descriptor.c
    ../../../../Libraries/drivers/K/src/usb/src/class/msc/: usb_msc.c usb_msc_scsi.c
  group driver\usb\dirver
    ../../../../Libraries/drivers/K/src/usb/src/driver/: usb_dci_kinetis.c usb_driver.c usbevent.c
  group driver\usb\commn
    ../../../../Libraries/drivers/K/src/usb/src/common/: usb.c usb_class.c usb_framework.c
  group test
    ../../../../Libraries/utilities/RT-Thread_1.2.0/components/init/: components.c
    ../../../../Libraries/utilities/RT-Thread_1.2.0/lib/src/: board.c startup.c
    ../../../../Libraries/utilities/RT-Thread_1.2.0/components/finsh/: shell.c
  group ssd_lib
    ../../../../Libraries/drivers/K/src/flash/lib/: MK_P1M0.lib MK_P512.lib
target mk64f12 (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: templete +hex
  AfterMake: fromelf --bin !L --output templete.bin
  c flags: Optim=4
  c define: MK64F12 RAVEN
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\drivers\K\inc;..\src\gui;..\src;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\include;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\finsh;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\dfs\include;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\dfs\filesystems\nfs;..\..\..\..\Libraries\utilities\emWin\Include;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\drivers\include;..\..\..\..\Libraries\devices\inc;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\bsp\Reven;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\init;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\net\lwip-1.4.1\src;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\net\lwip-1.4.1\src\arch\include;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\net\lwip-1.4.1\src\include;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\net\lwip-1.4.1\src\include\ipv4;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\net\lwip-1.4.1\src\include\netif;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\lib\src;..\..\..\..\Libraries\utilities\board;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\dfs\filesystems\romfs;..\src\webserver;..\..\..\..\Libraries\drivers\K\src\usb\inc;..\..\..\..\Libraries\drivers\K\src\usb\src\descriptor\msd;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\init;..\src\gui
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  link misc: as above
