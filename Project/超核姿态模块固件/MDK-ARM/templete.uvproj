# Keil uVision project templete.uvproj, settings and files
target mk10d5 (ARM-ADS)
  device: MK10DN32xxx5 Freescale Semiconductor
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20000FFF) IROM(0x0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: templete
  c flags: Optim=1
  c define: MK10D5 URANUS
  c misc: --c99
  c include: ..\..\..\Libraries\startup\CoreSupport;..\..\..\Libraries\startup\DeviceSupport;..\..\..\Libraries\drivers\K\inc;..\..\..\Libraries\devices\inc;..\..\..\Libraries\utilities\inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x1000
  group startup
    ../../../Libraries/startup/DeviceSupport/: system_MK10D5.c
    ../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK10D5.s
  group user
    ../src/: main.c trans.c
  group drivers
    ../../../Libraries/drivers/K/src/: clock.c cpuidy.c gpio.c i2c.c spi.c systick.c uart.c dma.c
  group utilities
    ../../../Libraries/utilities/imu/: imu.c
  group devices
    ../../../Libraries/devices/src/: bmp180.c hmc5883.c mpu6050.c 24l01.c i2c_abstraction.c spi_abstraction.c
