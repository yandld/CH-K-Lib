# Keil uVision project templete.uvproj, settings and files
target mk60dz10 (ARM-ADS)
  device: MK60DN512xxx10 Freescale Semiconductor
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") CLOCK(100000000) ELITTLE
  output: templete
  AfterMake: fromelf --bin !L --output templete.bin
  c flags: Optim=1
  c define: MK60DZ10 CHK60EVB2 DEBUG
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\drivers\K\inc;..\..\..\..\Libraries\devices\inc;..\src;..\..\..\..\RT-Thread_1.2.0\include;..\..\..\..\RT-Thread_1.2.0\components\finsh;..\..\..\..\RT-Thread_1.2.0\components\dfs\include;..\..\..\..\RT-Thread_1.2.0\components\rtgui\include\rtgui;..\..\..\..\RT-Thread_1.2.0\components\rtgui\include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_*
  group startup
    ../../../../Libraries/startup/DeviceSupport/: system_MK60DZ10.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK60DZ10.s
  group user
    ../src/: main.c rtconfig.h startup.c led_tesk.c cpuusage.c kill.c device_test.c
  group drivers
    ../../../../Libraries/drivers/K/src/: gpio.c uart.c wdog.c pit.c cpuidy.c adc.c ftm.c i2c.c spi.c lptmr.c dma.c flexbus.c systick.c rtc.c enet.c tsi.c common.c sd.c
  group devices
    ../../../../Libraries/devices/src/: ili9320.c sram.c spi_abstraction.c ads7843.c w25qxx.c i2c_abstraction.c adxl345.c at24cxx.c
  group rtt-kernel
    ../../../../RT-Thread_1.2.0/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group rtt-cortex-m4
    ../../../../RT-Thread_1.2.0/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../../RT-Thread_1.2.0/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group rtt-finsh
    ../../../../RT-Thread_1.2.0/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c shell.c symbol.c
  group rtt-driver
    ../../../../RT-Thread_1.2.0/bsp/Reven/: rtt_serial.c rtt_sd.c rtt_ili9320.c
  group rtt-dfs
    ../../../../RT-Thread_1.2.0/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../../../../RT-Thread_1.2.0/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../../../RT-Thread_1.2.0/components/dfs/filesystems/elmfat/option/: cc936.c
  group rtt-rtgui
    ../../../../RT-Thread_1.2.0/components/rtgui/common/: asc12font.c asc16font.c blit.c color.c dc.c dc_blend.c dc_buffer.c dc_client.c dc_hw.c filerw.c font.c font_bmp.c font_fnt.c font_freetype.c framebuffer_driver.c image.c image_bmp.c image_container.c image_hdc.c image_jpg.c image_png.c image_xpm.c pixel_driver.c region.c rtgui_app.c rtgui_mv_model.c rtgui_object.c rtgui_system.c rtgui_theme.c rtgui_xml.c
    ../../../../RT-Thread_1.2.0/components/rtgui/widgets/: box.c button.c checkbox.c combobox.c container.c digfont.c digtube.c edit.c filelist_view.c groupbox.c iconbox.c label.c list_view.c listbox.c listctrl.c menu.c mv_view.c notebook.c panel.c plot.c plot_curve.c progressbar.c radiobox.c scrollbar.c slider.c staticline.c textbox.c textview.c title.c widget.c window.c
    ../../../../RT-Thread_1.2.0/components/rtgui/server/: driver.c mouse.c server.c topwin.c
  group rtt-rtgui-examples
    ../../../../RT-Thread_1.2.0/examples/gui/: demo_application.c demo_plot.c demo_view.c demo_view_animation.c demo_view_benchmark.c demo_view_bmp.c demo_view_box.c demo_view_buffer_animation.c demo_view_button.c demo_view_checkbox.c demo_view_combobox.c demo_view_dc.c demo_view_dc_buffer.c demo_view_digtube.c demo_view_edit.c demo_view_instrument_panel.c demo_view_label.c demo_view_listbox.c demo_view_listctrl.c demo_view_menu.c demo_view_module.c demo_view_mywidget.c demo_view_notebook.c demo_view_progressbar.c demo_view_radiobox.c demo_view_scrollbar.c demo_view_slider.c demo_view_textbox.c demo_view_ttf.c demo_view_window.c demo_xml.c mywidget.c
