# Keil uVision project templete.uvproj, settings and files
target mk60f15 (ARM-ADS)
  device: MK60FN1M0xxx15 Freescale Semiconductor
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(150000000) ELITTLE
  output: templete +hex
  c flags: Optim=1
  c define: MK60F15 RAVEN LIB_DEBUG
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\drivers\K\inc;..\..\..\..\Libraries\utilities\inc;..\..\..\..\Libraries\devices\inc;..\src;..\..\..\..\Libraries\znfat;..\..\..\..\Libraries\emWin\Include;..\..\..\..\Libraries\emWin\Sample\LCD_X;..\src\demo
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group startup
    ../../../../Libraries/startup/DeviceSupport/: system_MK60F15.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK60F15.s
  group user
    ../src/: main.c boarddef.h mb85rc64.c unit_test.c asm_fun.asm uart0_isr.c uart3_isr.c uart4_isr.c uart5_isr.c pit0.c pit1.c
  group drivers
    ../../../../Libraries/drivers/K/src/: gpio.c uart.c wdog.c pit.c cpuidy.c adc.c ftm.c spi.c lptmr.c flexbus.c systick.c rtc.c tsi.c common.c i2c.c dma.c
  group DSP_Lib
    ../../../../Libraries/drivers/K/src/dsp/lib/: arm_cortexM4lf_math.lib
