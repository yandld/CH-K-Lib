# Keil uVision project demo.uvprojx, settings and files
target demo (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MK60DN512xxx10 Freescale
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: demo +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 wLevel=2
  c define: MK60D10,LIB_DEBUG
  c misc: --c99
  c include: ..\..\..\..\Libraries\drivers\K\inc;..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\devices\inc;..\..\..\..\Libraries\utilities\emWin\Include;..\..\..\..\Libraries\utilities\fatfs;..\h;..\..\..\..\Libraries\utilities\TJpegDec
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group startup_mk60d10
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK60D10.s
    ../../../../Libraries/startup/DeviceSupport/: system_MK60D10.c
  group usr
    ../src/: main.c usr_sdhc.c usr_jpeg_io.c
  group drivers
    ../../../../Libraries/drivers/K/src/: common.c flash.c flexbus.c gpio.c pdb.c pit.c sd.c systick.c uart.c
  group devices
    ../../../../Libraries/devices/src/: IS61WV25616.c ili9320.c
  group emWim_Lib
    ../../../../Libraries/utilities/emWin/Lib/: GUI_CM3.lib
  group emWim_Config
    ../../../../Libraries/utilities/emWin/Sample/Config/: LCDConf_FlexColor_Template.c GUIConf.c GUI_X.c
  group emWim_Pictures
    ../Pictures/: hankeku.c onepiece.c
  group fatfs
    ../../../../Libraries/utilities/fatfs/: diskio.c ff.c
  group assist
    ../../../../Libraries/utilities/TJpegDec/: tjpgd.c
