# Keil uVision project templete.uvprojx, settings and files
target mk64f12 (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: templete +hex
  c flags: Optim=4
  c misc: --c99
  c include: ..\src_app;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\include;..\..\..\..\Libraries\utilities\emWin\Include;..\..\..\..\Libraries\drivers\K\inc;..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\finsh;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\drivers\include;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\drivers\include\drivers;..\src_app\gui;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\dfs\include
  memory RVCT4: ROM 0x60000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  link misc: --datacompressor off
  group user
    ../src_app/: main.c
    ../src_app/gui/: gui_thread.c k_module.c k_menu.c k_startup.c
  group emwin
    ../../../../Libraries/utilities/emWin/Lib/: GUI_CM3.lib
    ../../../../Libraries/utilities/emWin/Sample/Config/: GUI_X_RTT.c GUIConf_RTT.c LCDConf_RTT.c
  group emwin/demo
    ../../../../Libraries/utilities/emWin/Sample/GUIDemo/: GUIDEMO.c GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
  group api_mk64
    ../MDK_Firmware/mk64f12/flash/: api_mk64.sym
