# Keil uVision project templete.uvprojx, settings and files
target mk22f12810 (5060020::V5.06 (build 20)::ARMCC)
  device: MK22FN128xxx10 Freescale
  pack: Keil.Kinetis_K20_DFP.1.3.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x4000) IRAM2(0x1FFFE000,0x2000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: templete +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1
  c define: MK22F12810
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\drivers\K\inc;..\..\..\..\Libraries\utilities\inc;..\..\..\..\Libraries\devices\inc;..\src
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  group user
    ../src/: main.c
  group drivers
    ../../../../Libraries/drivers/K/src/: gpio.c uart.c wdog.c pit.c cpuidy.c adc.c ftm.c i2c.c spi.c lptmr.c dma.c flexbus.c systick.c rtc.c enet.c tsi.c common.c sd.c can.c vref.c
  group startup_mk22f12810
    ../../../../Libraries/startup/DeviceSupport/: system_MK22F12810.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK22F12810.s
