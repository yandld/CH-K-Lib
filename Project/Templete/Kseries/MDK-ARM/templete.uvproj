# Keil uVision project templete.uvproj, settings and files
target mk10d5 (ARM-ADS)
  device: MK10DN32xxx5 Freescale Semiconductor
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20000FFF) IROM(0x0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: templete
  c flags: Optim=1
  c define: MK10D5
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\drivers\K\inc;..\..\..\..\Libraries\devices;..\..\..\..\Libraries\utilities
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x1000
  group startup
    ../../../../Libraries/startup/DeviceSupport/: system_MK10D5.c system_MK10D10.c system_MK20D10.c system_MK60D10.c system_MK60DZ10.c system_MK70F15.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK10D5.s startup_MK10D10.s startup_MK20D10.s startup_MK60D10.s startup_MK60DZ10.s startup_MK70F15.s
  group user
    ../src/: main.c cmd_gpio.c cmd_uart.c cmd_cpuinfo.c cmd_pit.c cmd_adc.c cmd_flexbus.c cmd_ftm.c cmd_reset.c cmd_nvic.c cmd_sram.c cmd_lcd.c cmd_i2c.c shell_config.h
  group drivers
    ../../../../Libraries/drivers/K/src/: clock.c cpuidy.c gpio.c i2c.c pit.c systick.c uart.c adc.c flexbus.c ftm.c
  group utilities
    ../../../../Libraries/utilities/shell/: shell.c shell_autocomplete.c shell_cmdhelp.c shell_cmdhist.c
  group devices
    ../../../../Libraries/devices/ili9320/: ili9320.c
    ../../../../Libraries/devices/sram/: sram.c
target mk60dz10 (ARM-ADS)
  device: MK60DN256xxx10 Freescale Semiconductor
  cpu: IRAM(0x1FFF8000-0x1FFFFFFF) IRAM2(0x20000000-0x20007FFF) IROM(0x0-0x4FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: templete
  c flags: Optim=1
  c define: MK60DZ10 CHK60EVB2
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\drivers\K\inc;..\..\..\..\Libraries\utilities\inc;..\..\..\..\Libraries\devices\inc;..\src
  memory RVCT4: ROM 0x0 size 0x50000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
target mk60d10 (ARM-ADS)
  device: MK60DN256xxx10 Freescale Semiconductor
  cpu: as above
  output: templete
  c flags: Optim=1
  c define: MK60D10
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\drivers\K\inc;..\..\..\..\Libraries\utilities;..\..\..\..\Libraries\devices
  memory RVCT4: ROM 0x0 size 0x50000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
target mk70f15 (ARM-ADS)
  device: MK70FN1M0xxx15 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: templete
  c flags: Optim=1
  c define: MK70F15
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
