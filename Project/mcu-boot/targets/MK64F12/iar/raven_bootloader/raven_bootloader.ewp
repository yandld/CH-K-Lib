# IAR project raven_bootloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MK64FN1M0VMD12; BL_TARGET_FLASH
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\src\include; ..\..\..\..\src\include\device; ..\..\..\..\src; ..\..\..\..\src\drivers; ..\..\..\..\src\startup; ..\..\..\..\src\autobaud; ..\..\..\..\src\drivers\uart; ..\..\..\..\src\drivers\mcg; ..\..\..\..\src\usb_device\driver; ..\..\..\..\src\usb_device\driver\kinetis; ..\..\..\..\src\usb_device\common; ..\..\..\..\src\usb_device\class; ..\..\..\..\src\usb_device\hid; ..\..\src; ..\..\..\..\src\utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: BL_TARGET_FLASH
  AARM.AUserIncludes: ..\..\..\..\src\include
  OBJCOPY.OOCOutputFile: tower_bootloader.srec
  ILINK.IlinkOutputFile: tower_bootloader.elf
  ILINK.IlinkIcfFile: ..\..\..\common\linker\iar\MK64F12\K64FN1Mxxx12_application_0x0000.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: TOWER; CPU_MK64FN1M0VMD12; NDEBUG; BL_TARGET_FLASH
  ICCARM.CCIncludePath2: ..\..\..\..\src\include; ..\..\..\..\src\include\device; ..\..\..\..\src; ..\..\..\..\src\autobaud; ..\..\..\..\src\drivers; ..\..\..\..\src\common; ..\..\..\..\src\startup; ..\..\..\..\src\drivers\uart; ..\..\..\..\src\drivers\mcg; ..\..\..\..\src\platforms; ..\..\..\..\src\usb_device\driver; ..\..\..\..\src\usb_device\driver\kinetis; ..\..\..\..\src\usb_device\common; ..\..\..\..\src\usb_device\class; ..\..\..\..\src\usb_device\hid; ..\..\src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: raven_bootloader.bin
  ILINK.IlinkOutputFile: raven_bootloader.out
  group k64f12
    ../../src/: bootloader_config.h clock_config_MK64F12.c hardware_init_MK64F12.c memory_map_MK64F12.c peripherals_MK64F12.c system_MK64F12.c target_config.h
  group link
    ../../../common/linker/iar/MK64F12/: K64FN1Mxxx12_application_0x0000.icf
  group src/autobaud
    ../../../../src/autobaud/: autobaud.h
  group src/autobaud/src
    ../../../../src/autobaud/src/: autobaud_irq.c
  group src/bootloader
    ../../../../src/bootloader/: bl_peripheral_interface.h bl_user_entry.h bl_version.h bootloader.h command.h context.h init_info.h peripheral.h shutdown_cleanup.h
  group src/bootloader/src
    ../../../../src/bootloader/src/: bl_user_entry.c bootloader.c bootloader_context.c bootloader_tree_root.c command.c scuart_peripheral_interface.c shutdown_cleanup.c
  group src/crc
    ../../../../src/crc/: crc16.h crc32.h
  group src/crc/src
    ../../../../src/crc/src/: crc16.c crc32.c
  group src/drivers/flash
    ../../../../src/drivers/flash/: flash.h
    ../../../../src/drivers/flash/src/: flash_cache_clear.c flash_command_sequence.c flash_densities_k_series.c flash_erase.c flash_erase_all.c flash_erase_all_unsecure.c flash_get_property.c flash_get_security_state.c flash_init.c flash_is_protected.c flash_program.c flash_program_once.c flash_read_once.c flash_read_resource.c flash_security_bypass.c flash_verify_erase.c flash_verify_erase_all.c flash_verify_program.c SSD_FTFx_Common.h
  group src/drivers/microseconds
    ../../../../src/drivers/microseconds/: microseconds.h
  group src/drivers/microseconds/src
    ../../../../src/drivers/microseconds/src/: microseconds_sysclk.c
  group src/drivers/uart
    ../../../../src/drivers/uart/: scuart.c scuart.h
  group src/include
    ../../../../src/include/: fsl_platform_common.h fsl_platform_status.h fsl_platform_types.h
  group src/memory
    ../../../../src/memory/: memory.h
  group src/memory/src
    ../../../../src/memory/src/: flash_memory.c memory.c normal_memory.c normal_memory.h pattern_fill.h pattern_fill.s sram_init_cm4.c
  group src/packet
    ../../../../src/packet/: command_packet.h serial_packet.h
  group src/packet/src
    ../../../../src/packet/src/: serial_packet.c
  group src/property
    ../../../../src/property/: property.h
  group src/property/src
    ../../../../src/property/src/: property.c
  group src/sbloader
    ../../../../src/sbloader/: sbloader.h
  group src/sbloader/src
    ../../../../src/sbloader/src/: sbloader.c
  group src/startup
    ../../../../src/startup/: crt0.s startup.c
    ../../../../src/startup/MK64F12/iar/: startup_MK64F12.s
  group src/utilities
    ../../../../src/utilities/src/: fsl_assert.c fsl_rtos_abstraction.c
