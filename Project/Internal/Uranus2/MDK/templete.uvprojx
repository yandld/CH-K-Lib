# Keil uVision project templete.uvprojx, settings and files
target mkl26z4 (5060020::V5.06 (build 20)::ARMCC)
  device: MKL25Z64xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.7.0
  cpu: IROM(0x00000000,0x10000) IRAM(0x1FFFF800,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: templete +hex
  c flags: Optim=3 oTime=1 uC99=1
  c define: MKL26Z4 CLOCK_SETUP=0 URANUS2 CHLIB_DMA_SUPPORT=1
  c include: ..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\drivers\KL\inc;..\..\..\..\Libraries\devices\inc;..\..\..\..\Libraries\utilities\board;..\..\..\..\Libraries\utilities\imu;..\..\..\..\Libraries\drivers\K\src\usb\inc;..\..\..\..\Libraries\utilities\veep;..\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x1ffff800 size 0x2000
  group startup_mkl26z4
    ../../../../Libraries/startup/DeviceSupport/: system_MKL26Z4.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MKL26Z4.s
  group user
    ../src/: main.c protocol.c mq.c isr.c
    ../../../../Libraries/utilities/veep/: virtual_eep.c
  group drivers
    ../../../../Libraries/drivers/KL/src/: common.c dma.c flash.c gpio.c i2c.c pit.c uart.c lptmr.c
  group utilities
    ../../../../Libraries/utilities/imu/: filter.c imu.c calibration.c
  group devices
    ../../../../Libraries/devices/src/: mpu9250.c bmp180.c
  group config
    ../src/: appdef.h
target mkl26z4_bootloader (5060020::V5.06 (build 20)::ARMCC)
  device: MKL25Z64xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.7.0
  cpu: as above
  output: templete +hex
  c flags: Optim=1 uC99=1
  c define: MKL26Z4 CLOCK_SETUP=0 URANUS2 CHLIB_DMA_SUPPORT=1 BOOTLOADER
  c include: as above
  asm define: BOOTLOADER
  library: MicroLIB
  memory RVCT4: ROM 0x5000 size 0x10000
  memory RVCT9: RAM 0x1ffff800 size 0x2000
target mkl26z4_only_eular (5060020::V5.06 (build 20)::ARMCC)
  device: MKL25Z64xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.7.0
  cpu: as above
  output: templete +hex
  c flags: Optim=1 uC99=1
  c define: MKL26Z4 CLOCK_SETUP=0 URANUS2 CHLIB_DMA_SUPPORT=1 ONLY_EULAR
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x1ffff800 size 0x2000
