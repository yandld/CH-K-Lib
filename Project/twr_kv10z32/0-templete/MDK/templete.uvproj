# Keil uVision project templete.uvproj, settings and files
target mkv10z7_flash (ARM-ADS)
  device: MKV10Z32xxx7 Freescale
  pack: Keil.Kinetis_KVxx_DFP.1.2.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x20000000,0x1800) IRAM2(0x1FFFF800,0x0800) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: templete +hex
  AfterMake: fromelf --bin !L --output ./OBJ/flash/templete.bin
  c flags: Optim=1
  c define: MKV10Z7 RAVEN DEBUG
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\drivers\K\inc;..\..\..\..\Libraries\utilities\inc;..\..\..\..\Libraries\devices\inc;..\src;..\..\..\..\Libraries\znfat;..\..\..\..\Libraries\emWin\Include;..\..\..\..\Libraries\emWin\Sample\LCD_X
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  memory RVCT10: RAM 0x1ffff800 size 0x800
  group startup
    ../../../../Libraries/startup/DeviceSupport/: system_MKV10Z7.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MKV10Z7.s
  group user
    ../src/: main.c
  group drivers
    ../../../../Libraries/drivers/KV/src/: common.c gpio.c systick.c uart.c
