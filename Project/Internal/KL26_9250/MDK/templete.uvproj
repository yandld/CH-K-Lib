# Keil uVision project templete.uvproj, settings and files
target mkl26z4_flash (ARM-ADS)
  device: MKL25Z64xxx4 Freescale Semiconductor
  cpu: IROM(0x00000000,0x10000) IRAM(0x1FFFF800,0x2000) CPUTYPE("Cortex-M0+") CLOCK(48000000) ELITTLE
  output: templete +hex
  AfterMake: fromelf --bin !L --output ./mkl26z4/flash/templete.bin
  c flags: Optim=4 uC99=1
  c define: MKL26Z4 MOTION_DRIVER_TARGET_MSP430 MPU9250
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\drivers\KL\inc;..\..\..\..\Libraries\utilities\inc;..\..\..\..\Libraries\devices\inc;..\src;..\..\..\..\Libraries\znfat;..\..\..\..\Libraries\emWin\Include;..\..\..\..\Libraries\emWin\Sample\LCD_X;..\..\..\..\Libraries\utilities\imu;..\src\eMPL
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x1ffff800 size 0x2000
  group startup_mkl26z4
    ../../../../Libraries/startup/DeviceSupport/: system_MKL26Z4.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MKL26Z4.s
  group user
    ../src/: main.c protocol.c dmp.c
    ../../../../Libraries/devices/src/: mpu9250.c
    ../src/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group drivers
    ../../../../Libraries/drivers/KL/src/: common.c gpio.c systick.c uart.c i2c.c pit.c dma.c
  group imu
    ../../../../Libraries/utilities/imu/: imu.c
