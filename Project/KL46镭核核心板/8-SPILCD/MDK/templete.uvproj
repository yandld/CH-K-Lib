# Keil uVision project templete.uvproj, settings and files
target mkl46z_flash (ARM-ADS)
  device: MKL46Z256xxx4 Freescale
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x6000) IRAM2(0x1FFFE000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: templete +hex
  AfterMake: fromelf --bin !L --output ./OBJ/flash/templete.bin
  c flags: Optim=1
  c define: MKL46Z4 RADIUM
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\drivers\KL\inc;..\..\..\..\Libraries\utilities\inc;..\..\..\..\Libraries\devices\inc;..\src;..\..\..\..\Libraries\emWin\Include;..\..\..\..\Libraries\emWin\Sample\LCD_X;..\..\..\..\Libraries\utilities\board;..\..\..\..\Libraries\utilities\chgui
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  group startup
    ../../../../Libraries/startup/DeviceSupport/: system_MKL46Z4.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MKL46Z4.s
  group user
    ../src/: main.c
  group drivers
    ../../../../Libraries/drivers/KL/src/: common.c gpio.c systick.c uart.c adc.c dma.c i2c.c lptmr.c pit.c tpm.c spi.c
  group utilities/chgui
    ../../../../Libraries/utilities/chgui/: chgui.c
  group device
    ../../../../Libraries/devices/src/: ili9163.c spi_bus_ops_kl.c
