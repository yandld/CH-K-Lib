# Keil uVision project templete.uvproj, settings and files
target mk64f12_flash (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: templete +hex
  AfterMake: fromelf --bin !L --output ./OBJ/flash/templete.bin
  c flags: Optim=1
  c define: MK64F12 FRDM LIB_DEBUG
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\drivers\K\inc;..\..\..\..\Libraries\utilities\inc;..\..\..\..\Libraries\devices\inc;..\src;..\..\..\..\Libraries\znfat;..\..\..\..\Libraries\emWin\Include;..\..\..\..\Libraries\emWin\Sample\LCD_X;..\..\..\..\Libraries\utilities\shell;..\..\..\..\Libraries\utilities\board
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  link misc: --keep __fsym_*
  group startup
    ../../../../Libraries/startup/DeviceSupport/: system_MK64F12.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK64F12.s
  group user
    ../src/: main.c
  group drivers
    ../../../../Libraries/drivers/K/src/: common.c gpio.c uart.c systick.c dma.c pit.c rtc.c adc.c spi.c vref.c wdog.c i2c.c lptmr.c ftm.c enet.c cpuidy.c pdb.c sd.c
  group shell
    ../../../../Libraries/utilities/shell/: shell.c shell_autocomplete.c shell_cmdhelp.c shell_cmdhist.c
  group devices
    ../../../../Libraries/devices/src/: ksz8041.c
  group hw_test
    ../../../../Libraries/utilities/board/: cmd_test_gpio.c cmd_test_i2c.c cmd_test_pit.c cmd_test_uart.c cmd_test_lptmr.c cmd_test_adc.c cmd_test_key.c cmd_test_dma.c cmd_test_wdog.c cmd_test_clkout.c cmd_test_pdb.c cmd_test_ftm.c cmd_test_rtc.c cmd_test_sd.c cmd_test_enet.c
